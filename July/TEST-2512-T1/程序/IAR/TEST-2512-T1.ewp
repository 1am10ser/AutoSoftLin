# IAR project TEST-2512-T1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S005C6 STM8S005C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\LIB; ..\LIB\inc; ..\LIB\src; ..\USR; ..\DRV
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: TEST-2512-T1.hex
  ILINK.IlinkOutputFile: TEST-2512-T1.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S007C8 STM8S007C8
  ICCSTM8.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: TesterProductB.out
  group DRV
    ../DRV/: 74hc164.c 74hc164.h 74hc165.c 74hc165.h 74hc595.c 74hc595.h adc2.c adc2.h CONNECT.c CONNECT.h ioext.c ioext.h key.c key.h lcd.c lcd.h lcd_fonts.c lcd_fonts.h lcd_msp3520.c lcd_msp3520.h motor.c motor.h tim1.c tim1.h tim2.c tim2.h tim3.c tim3.h
  group LIB
    ../LIB/inc/: stm8s.h stm8s_adc2.h stm8s_flash.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim3.h
    ../LIB/src/: stm8s_adc2.c stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c
    ../LIB/: stm8s_conf.h
  group USR
    ../USR/: common.c common.h main.c stm8s_it.c
