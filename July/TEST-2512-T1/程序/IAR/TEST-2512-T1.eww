<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TEST-2512-T1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


