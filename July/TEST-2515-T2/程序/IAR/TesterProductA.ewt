<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>DRV</name>
    <file>
      <name>$PROJ_DIR$\..\DRV\74hc164.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\74hc164.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\74hc165.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\74hc165.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\74hc595.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\74hc595.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\a4988.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\a4988.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\adc2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\adc2.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\connect.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\connect.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\key.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\lcd.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\lcd_st7735s.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\lcd_st7735s.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\led.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\lin.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\lin.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\lin.m.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\lin.m.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\lin.s.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\lin.s.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\tim1.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\tim2.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\tim3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\tim3.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\uart1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\uart1.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\uart3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\DRV\uart3.h</name>
    </file>
  </group>
  <group>
    <name>LIB</name>
    <file>
      <name>$PROJ_DIR$\..\LIB\inc\stm8s.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\src\stm8s_adc2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\inc\stm8s_adc2.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\src\stm8s_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\stm8s_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\src\stm8s_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\src\stm8s_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\inc\stm8s_spi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\src\stm8s_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\inc\stm8s_tim1.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\src\stm8s_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\inc\stm8s_tim2.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\src\stm8s_tim3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\inc\stm8s_tim3.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\src\stm8s_uart1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\inc\stm8s_uart1.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\src\stm8s_uart3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\inc\stm8s_uart3.h</name>
    </file>
  </group>
  <group>
    <name>USR</name>
    <file>
      <name>$PROJ_DIR$\..\USR\common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USR\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USR\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USR\stm8s_it.c</name>
    </file>
  </group>
</project>


